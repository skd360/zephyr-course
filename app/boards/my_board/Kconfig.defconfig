## homework_codes/l5-task2/my_board/board.yml
```yaml
board:
  name: my_board
  full_name: My Board From Scrath
  vendor: iomico
  socs:
    - name: stm32f446xx
```
